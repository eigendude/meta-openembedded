require python-lockfile.inc

inherit setuptools3
