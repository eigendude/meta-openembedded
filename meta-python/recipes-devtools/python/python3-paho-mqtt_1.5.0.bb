# Generated with "pipoe --default-license EPL-1.0 -p paho-mqtt"

SUMMARY = "MQTT version 3.1.1 client class"
HOMEPAGE = "http://eclipse.org/paho"
AUTHOR = "Roger Light <roger@atchoo.org>"
LICENSE = "EPL-1.0"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=eb48c6ee2cb9f5b8b9fe75e6f817bdfc"

SRC_URI = "https://files.pythonhosted.org/packages/59/11/1dd5c70f0f27a88a3a05772cd95f6087ac479fac66d9c7752ee5e16ddbbc/paho-mqtt-1.5.0.tar.gz"
SRC_URI[md5sum] = "45e80d9b8066a8d0ba1ecfffe271bd3d"
SRC_URI[sha256sum] = "e3d286198baaea195c8b3bc221941d25a3ab0e1507fc1779bdb7473806394be4"

S = "${WORKDIR}/paho-mqtt-1.5.0"

inherit setuptools3
